FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-am335x-baltos-enable-mPCIe-slot-by-default.patch"
